*******************************************************************************
*** CONTROL OPTIONS ***********************************************************
*******************************************************************************

*******************************************************************************
*** INCLUDES ******************************************************************
*******************************************************************************

*******************************************************************************
*** PARAMETERS ****************************************************************
*******************************************************************************

.include 'deemb_kolding00_params.sp'

*******************************************************************************
*** SUBCIRCUITS ***************************************************************
*******************************************************************************

*******************************************************************************
*** CIRCUIT *******************************************************************
*******************************************************************************

P1 n1 GND port=1

RZcs1 n1 n1x 'Zc'
RZcg1 GND n1z 'Zc/2'
RZp1 n1x n1z 'Zp'

Rshort1 n1x n1z 1e-5

RZcs2 n2 n2x 'Zc'
RZcg2 GND n2z 'Zc/2'
RZp2 n2x n2z 'Zp'

Rshort2 n2x n2z 1e-5

P2 n2 GND port=2

*******************************************************************************
*** ANALYSIS ******************************************************************
*******************************************************************************

.ac lin 100 1 300G
.lin sparcalc=1 format=touchstone filename=deemb_kolding00_simple_short

*******************************************************************************
*** SAVED DATA ****************************************************************
*******************************************************************************

*******************************************************************************
*** HSPICE OPTIONS ************************************************************
*******************************************************************************

.option post nomod brief parhier=local

.end
